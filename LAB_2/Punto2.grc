options:
  parameters:
    author: Manuel_Solano_Fabian_Jimenez_j1B_grupo2
    generate_options: qt_gui
    id: Lab1_punto2
    output_language: python
    title: Lab1_punto2_Muestreo
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: 1k
    step: 1k
    stop: 40k
    value: 2k
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: 1k
    step: 1k
    stop: 80k
    value: 10k
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
